# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Drivers
  group Source Group 1
    ./Drivers/: DEV51.c LCD1602.c DS18B20.c KEY.c
    ./Tasks/: MainTask.c
